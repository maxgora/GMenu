# Keil uVision project GMenu.uvprojx, settings and files
target GMenu (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F207IGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: GMenu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_HAL_DRIVER,STM32F207xx
  c include: ../Inc;                  ../Drivers/STM32F2xx_HAL_Driver/Inc;                  ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;                  ../Middlewares/Third_Party/FreeRTOS/Source/include;                  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                  ../Drivers/CMSIS/Device/ST/STM32F2xx/Include;                  ../Drivers/CMSIS/Include;               ../Src;                  ../TM_Lib;                 ../uGfx_Lib;                ../uGfx_Lib/drivers/gdisp/ST7735;         ../Pictures;         ../Fonts;        ../uGfx_Lib/drivers/ginput/toggle/Pal/
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User
    ../Src/: ecg.c hooks.c freertos.c main.c my_main.c pins.c stm32f2xx_it.c stm32f2xx_hal_msp.c stm32f2xx_hal_timebase_tim.c val.c utils.c utils_tst.c measure.c
  group Application/User/Shell
    ../Src/: screen_mng.c header.c DrawIco.c screen0.c screen1.c screen2.c screen3.c screen4.c screen5.c screen6.c screen7.c screen8.c screen9.c screen10.c screen11.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_fsmc.c stm32f2xx_hal_sram.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group TM_Lib
    ../TM_Lib/: tm_stm32_button.c tm_stm32_gpio.c
  group GfxLib
    ../uGfx_Lib/src/: gfx_mk.c
    ../uGfx_Lib/drivers/gdisp/ST7735/: gdisp_lld_ST7735.c
software components: CMSIS:CORE 4.3.0
